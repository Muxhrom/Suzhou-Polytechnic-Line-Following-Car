# Keil uVision project car3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: car3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c oled.c oled.h motor.c motor.h track.c track.h gate.c gate.h
